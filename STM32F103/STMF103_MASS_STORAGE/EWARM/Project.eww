<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STMF103_MASS_STORAGE.ewp</path>
  </project>
  <batchBuild />
</workspace>
